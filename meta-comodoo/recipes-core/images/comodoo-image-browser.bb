require comodoo-image-x11.bb

IMAGE_INSTALL_append = " \
    firefox \
    "

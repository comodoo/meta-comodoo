require recipes-graphics/images/core-image-x11.bb

COMODOO_DIR = "/opt/comodoo"

COMODOO_BINDIR = "${COMODOO_DIR}/bin"
COMODOO_DATADIR = "${COMODOO_DIR}/share"
COMODOO_ETCDIR = "${COMODOO_DIR}/etc"
COMODOO_LIBDIR = "${COMODOO_DIR}/lib"

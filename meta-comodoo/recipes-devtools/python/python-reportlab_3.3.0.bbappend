DEPENDS := "${@'${DEPENDS}'.replace('python-pillow', 'python-imaging')}"

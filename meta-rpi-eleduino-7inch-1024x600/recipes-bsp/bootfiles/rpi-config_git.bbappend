FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = " file://0001-Config-for-Eleduino-7.0-Inch-1024x600.patch"

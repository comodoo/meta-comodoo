SRCREV = "37ccd6e64a7f8e22d69a2d56a68f8e586f3145bf"
SRC_URI = "git://github.com/comodoo/RPi-config.git;protocol=git;branch=master \
          "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = " file://0001-Modify-to-be-used-in-comodoo-project.patch"
